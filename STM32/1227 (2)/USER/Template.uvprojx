# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\BLUETOOTH;..\HARDWARE\OLED;..\HARDWARE\IIC;..\HARDWARE\CONTROL;..\HARDWARE\MOTO;..\HARDWARE\MOTOR_ENCODER;..\HARDWARE\IWDG;..\HARDWARE\MOTOR_PID_TIME;..\HARDWARE\K210;..\HARDWARE\USART6;..\HARDWARE\HCSR04;..\HARDWARE\SERVO;..\HARDWARE\ADC;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050_EXIT;..\HARDWARE\XINHAO;..\HARDWARE\HALL_SENSOR;..\HARDWARE\LY38;..\HARDWARE\MICRO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/MOTO/: Moto.c
    ../HARDWARE/MOTOR_ENCODER/: Motor_Encoder.c
    ../HARDWARE/MOTOR_PID_TIME/: Motor_Pid_Time.c
    ../HARDWARE/K210/: k210.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/HCSR04/: hs_sr04.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/XINHAO/: xinhao.c
    ../HARDWARE/HALL_SENSOR/: Hall_Sensor.c
    ../HARDWARE/LY38/: Yl_Sensor.c
    ../HARDWARE/MICRO/: micro.c
